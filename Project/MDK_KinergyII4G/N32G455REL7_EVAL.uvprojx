# Keil uVision project N32G455REL7_EVAL.uvprojx, settings and files
target N32G455RE_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G455REL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: N32G455REL7_App +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,KINERGY_II_4G,N32G45X,USE_STDPERIPH_DRIVER,LV_CONF_INCLUDE_SIMPLE,USE_EMBEDDED_PHY,USE_USB_HS
  c misc: --diag_suppress=68  --diag_suppress=111  --diag_suppress=550
  c include: ..\..\FreeRTOS;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM4F;.\Source\develop\01_develop_tsk;.\Source\sdk\01_tsk;.\Source\sdk\02_software_api;.\Source\sdk\04_bsp;..\..\Firmware\CMSIS\device;..\..\Firmware\CMSIS\core;..\..\Firmware\n32g45x_std_periph_driver\inc;.\Source\sdk\00_Bootloader
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\GD32450I_App.sct
  group 00_Bootloader
    ./Source/sdk/00_Bootloader/: BootFlashCode.c BootIICCode.c BootLoader.c BootloaderAPP.c BootSpiFlashCode.c BootUARTCode.C BootloaderAsmFuncs_Keil.s InterruptJmpTable_Keil.s
  group 01_develop_tsk
    ./Source/develop/01_develop_tsk/: main.c n32g45x_it.c
  group 01_tsk
    ./Source/sdk/01_tsk/: tsk_commu_receive.c tsk_commu_send.c tsk_4g_init.c
  group 02_software_api
    ./Source/sdk/02_software_api/: crc16.c md5.c
  group 04_bsp
    ./Source/sdk/04_bsp/: bsp_log_manager.c bsp_serial_driver.c bsp_spiflash.c bsp_uart_ring_buffer.c led.c ring_buffer.c
  group CMSIS
    ../../Firmware/CMSIS/device/: system_n32g45x.c
  group Startup
    ../../Firmware/CMSIS/device/startup/: startup_n32g45x.s
  group FreeRTOS
    ../../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../FreeRTOS/portable/MemMang/: heap_4.c
    ../../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group n32g45x_std_periph_driver
    ../../Firmware/n32g45x_std_periph_driver/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c
software components: Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
