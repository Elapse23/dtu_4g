<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\kinergy_ii_4g.ewp</path>
    </project>
    <batchBuild />
</workspace>
