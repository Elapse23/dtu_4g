# IAR project kinergy_ii_4g.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: N32G455RE Nations N32G455RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __FPU_PRESENT=1
  ICCARM.CCIncludePath2: source\mcu\core; source\mcu\device; source\mcu\device\startup; source\mcu\peripheral\inc; source\app; source\app\include; source\rtos\freertos; source\rtos\freertos\kernel\include; source\rtos\freertos\kernel\portable\IAR\ARM_CM4F; source\driver\uart\rs485; source\driver\uart\lte; source\driver\uart\log; source\driver\i2c; source\driver\spi_flash; source\mcu\interrupt; source\hal\include; source\hal\include\IOTModule; source\hal\include\IOTModule\Common; source\hal\include\IOTModule\LTE Module; source\app\sourse\Network Communication\Inlcude; source\common\Include; source; source\app\sourse\System Info\Protocal Data Convert\Device Type\System; source\hal\Exrern Flash Operate; source\hal\Exrern Flash Operate\SPI Flash Operate; source\app\sourse\System Info\Network Data Info\Common; source\app\sourse\System Info\Common; source\app\sourse\Wired Network\Common; source\app\sourse\System Info\Network Data Info\System Info\System Type; source\app\sourse\System Info\Network Data Info\System Info\System Type\kinergy_ii; source\app\sourse\System Info\Network Data Info\Device Info\Device Type\System; source\app\sourse\System Info\Network Data Info\Device Info\Device Type\kinergy_ii; source\app\sourse\Wired Network\Rs485 Network\include; source\hal\include\rs485_transmission; source\app\sourse\System Info\Network Data Info\Device Info\Device Type\cklcd; source\app\sourse\System Info\Network Data Info\Device Info\Device Type\ck_inverter; source\app\sourse\System Info\Protocal Data Convert\Device Type\cklcd\Procotal Type\RS485; source\driver\led; source\driver\key; source\app\sourse\System Info\Network Data Info\Device Info\Device Type\mppt; source\app\sourse\System Info\Network Data Info\Device Info\Device Type\pv; source\Bootloader; source\app\sourse\System Info\Network Data Info\Device Info\Device Type\kinergy; source\app\sourse\System Info\Network Data Info\Device Info\Device Type\meter
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: source\rtos\freertos\kernel\include
  OBJCOPY.OOCOutputFile: Upsilon4001 00.10.0128 b01.10(08004FFF).srec
  ILINK.IlinkOutputFile: kinergy_ii.out
  ILINK.IlinkIcfFile: source\mcu\device\N32G455xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    source/app/sourse/: application_general_func.c crc16_arithmetic.c crc16_table.c display_management.c display_management_queue.c product_test.c system_timestamp_generate.c
    source/app/: main.c
  group app/network_communication
    source/app/sourse/Network Communication/Source/: net_firmware_update.c net_segmented_inquire.c network_4g_tbb_device_server_communicate.c network_ble_communication.c network_ble_communication_queue.c network_communication.c network_communication_queue.c network_device_config.c network_device_config_sycn.c network_energy_statistics.c network_eventlog_info_operate.c network_iot_module_data_channel_manage.c network_iot_module_data_queue.c network_local_config.c network_local_device_secquence_operate.c network_local_firmware_update.c network_local_secquence_generate.c network_offline_data_operate.c network_protocal.c network_protocal_data_assembly.c network_server_response_queue.c network_system_type_operate.c network_tbb_device_server_communicate.c
  group app/network_communication/system_info/net_data_info/common
    source/app/sourse/System Info/Network Data Info/Common/: device_data_attribute.c device_data_attribute.h net_active_push_data_build.c net_active_push_data_build.h net_attribute_tree_build.c net_attribute_tree_build.h net_device_data.h net_device_data_attribute.c net_device_data_attribute.h net_device_data_polling.c net_device_data_polling.h net_device_info.c net_device_info.h net_device_status.h net_device_tree.h net_device_tree_build.c net_device_tree_build.h net_device_tree_relation.h net_firmware_update_info.h net_real_time_data_build.c net_real_time_data_build.h net_system_info.c net_system_info.h net_system_info_access.c
  group app/network_communication/system_info/net_data_info/device_info
    source/app/sourse/System Info/Network Data Info/Common/: net_system_info_access.h
  group app/network_communication/system_info/net_data_info/device_info/device_type/ck_inverter
    source/app/sourse/System Info/Network Data Info/Device Info/Device Type/ck_inverter/: net_device_data_ck_inverter.c net_device_data_ck_inverter.h net_device_set_attribute_ck_inverter.c net_device_set_attribute_ck_inverter.h net_device_status_ck_inverter.c net_device_status_ck_inverter.h net_device_tree_ck_inverter.c net_device_tree_ck_inverter.h
  group app/network_communication/system_info/net_data_info/device_info/device_type/cklcd
    source/app/sourse/System Info/Network Data Info/Device Info/Device Type/cklcd/: net_device_data_cklcd.c net_device_data_cklcd.h net_device_set_attribute_cklcd.c net_device_set_attribute_cklcd.h net_device_status_cklcd.c net_device_status_cklcd.h net_device_tree_cklcd.c net_device_tree_cklcd.h
  group app/network_communication/system_info/net_data_info/device_info/device_type/kenergy_ii
    source/app/sourse/System Info/Network Data Info/Device Info/Device Type/kinergy_ii/: net_device_data_kinergy_ii.c net_device_data_kinergy_ii.h net_device_status_kinergy_ii.c net_device_status_kinergy_ii.h net_device_tree_kinergy_ii.c net_device_tree_kinergy_ii.h
  group app/network_communication/system_info/net_data_info/device_info/device_type/kinergy
    source/app/sourse/System Info/Network Data Info/Device Info/Device Type/kinergy/: net_device_data_kinergy.c net_device_data_kinergy.h net_device_set_attribute_kinergy.c net_device_set_attribute_kinergy.h net_device_status_kinergy.c net_device_status_kinergy.h net_device_tree_kinergy.c net_device_tree_kinergy.h
  group app/network_communication/system_info/net_data_info/device_info/device_type/meter
    source/app/sourse/System Info/Network Data Info/Device Info/Device Type/meter/: net_device_data_meter.c net_device_data_meter.h net_device_status_meter.c net_device_status_meter.h net_device_tree_meter.c net_device_tree_meter.h
  group app/network_communication/system_info/net_data_info/device_info/device_type/mppt
    source/app/sourse/System Info/Network Data Info/Device Info/Device Type/mppt/: net_device_data_mppt.c net_device_data_mppt.h net_device_status_mppt.c net_device_status_mppt.h net_device_tree_mppt.c net_device_tree_mppt.h
  group app/network_communication/system_info/net_data_info/device_info/device_type/pv
    source/app/sourse/System Info/Network Data Info/Device Info/Device Type/pv/: net_device_data_pv.c net_device_data_pv.h net_device_status_pv.c net_device_status_pv.h net_device_tree_pv.c net_device_tree_pv.h
  group app/network_communication/system_info/net_data_info/device_info/device_type/system
    source/app/sourse/System Info/Network Data Info/Device Info/Device Type/System/: net_device_data_system.c net_device_data_system.h net_device_status_system.c net_device_status_system.h net_device_tree_system.c net_device_tree_system.h
  group app/network_communication/system_info/net_data_info/device_info/system_info/system_type
    source/app/sourse/System Info/Network Data Info/System Info/System Type/: net_system_info_list.c net_system_info_list.h
  group app/network_communication/system_info/net_data_info/device_info/system_info/system_type/kenergy_ii
    source/app/sourse/System Info/Network Data Info/System Info/System Type/kinergy_ii/: net_device_id_kinergy_ii.c net_device_id_kinergy_ii.h net_device_info_kinergy_ii.c net_device_info_kinergy_ii.h net_device_tree_relation_kinergy_ii.c net_device_tree_relation_kinergy_ii.h net_firmware_info_kinergy_ii.c net_firmware_info_kinergy_ii.h
  group app/network_communication/system_info/protocal_data_convert/device_type/cklcd/rs485
    source/app/sourse/System Info/Protocal Data Convert/Device Type/cklcd/Procotal Type/RS485/: data_convert_rs485_net_cklcd.c data_convert_rs485_net_cklcd.h
  group app/network_communication/system_info/protocal_data_convert/device_type/system
    source/app/sourse/System Info/Protocal Data Convert/Device Type/System/: net_device_data_access.c net_device_data_access.h
  group app/network_communication/wired_netwok/Common
    source/app/sourse/Wired Network/Common/: wired_network_config_general.c
  group app/network_communication/wired_netwok/rs485_network
    source/app/sourse/Wired Network/Rs485 Network/sourse/: rs485_communicate_ex_call.c rs485_communicate_protocal.c
  group Bootloader
    source/Bootloader/: BootFlashCode.c BootIICCode.c BootLoader.c BootloaderAPP.c BootloaderAsmFuncs.asm BootloaderConfig.h BootloaderHead.H BootSpiFlashCode.c BootUARTCode.C InterruptJmpTable.asm
  group common
    source/common/Source/: msg_queue.c msg_queue_operate.c
  group driver/i2c
    source/driver/i2c/: Eeprom.c Eeprom.h IICDriver.c IICDriver.H
  group driver/key
    source/driver/key/: key.c key.h key_operate.c key_operate.h
  group driver/led
    source/driver/led/: led.c led.h
  group driver/spi_flash
    source/driver/spi_flash/: drv_spiflash.c drv_spiflash.h
  group driver/uart/log
    source/driver/uart/log/: usart_config_log.c usart_config_log.h
  group driver/uart/lte
    source/driver/uart/lte/: usart_config_lte.c usart_config_lte.h
  group driver/uart/rs485
    source/driver/uart/rs485/: rs485.c rs485.h
  group hal
    source/hal/include/: debug_printf_manage.h
    source/hal/sourse/: printf_custom.c
  group hal/extern_flash_operate
    source/hal/Exrern Flash Operate/: extern_flash_operate.c extern_flash_operate.h
    source/hal/Exrern Flash Operate/SPI Flash Operate/: spi_flash_address_allocate.h spi_flash_operate.c spi_flash_operate_queue.c
  group hal/iot_module
    source/hal/sourse/IOT Module/: iot_module_config_general.c
  group hal/iot_module/common
    source/hal/sourse/IOT Module/Common/: iot_module_config_common.c
  group hal/iot_module/lte_module
    source/hal/sourse/IOT Module/LTE Module/: lte_4g_module.c lte_4g_module_ble_at_driver.c lte_4g_module_stander_at_driver.c lte_4g_module_tcp_at_driver.c lte_ftp_updata.c lte_module.c lte_module_ble_at_driver.c lte_module_com_interface_init.c lte_module_config_common.c lte_module_config_queue.c lte_module_data_queue.c lte_module_stander_at_driver.c lte_module_tcp_at_driver.c
  group hal/rs485_transmission
    source/hal/sourse/rs485_transmission/: rs485_communication_transmission.c rs485_communication_tx_queue.c
  group mcu/device
    source/mcu/device/: N32G455xC.icf n32g45x.h n32g45x_conf.h system_n32g45x.c system_n32g45x.h
    source/mcu/device/startup/: startup_n32g45x_EWARM.s
  group mcu/interrupt
    source/mcu/interrupt/: n32g45x_it.c n32g45x_it.h
  group mcu/peripheral
    source/mcu/peripheral/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c n32g45x_xfmc.c
    source/mcu/peripheral/inc/: misc.h n32g45x_adc.h n32g45x_bkp.h n32g45x_can.h n32g45x_comp.h n32g45x_crc.h n32g45x_dac.h n32g45x_dbg.h n32g45x_dma.h n32g45x_dvp.h n32g45x_eth.h n32g45x_exti.h n32g45x_flash.h n32g45x_gpio.h n32g45x_i2c.h n32g45x_iwdg.h n32g45x_opamp.h n32g45x_pwr.h n32g45x_qspi.h n32g45x_rcc.h n32g45x_rtc.h n32g45x_sdio.h n32g45x_spi.h n32g45x_tim.h n32g45x_tsc.h n32g45x_usart.h n32g45x_wwdg.h n32g45x_xfmc.h
  group rtos/freertos
    source/rtos/freertos/: freertos_user_config.c freertos_user_config.h
    source/rtos/freertos/kernel/include/: FreeRTOSConfig.h
  group rtos/freertos/core
    source/rtos/freertos/kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group rtos/freertos/portable
    source/rtos/freertos/kernel/portable/MemMang/: heap_4.c
    source/rtos/freertos/kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
